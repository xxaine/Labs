<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\lab2\checks.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Desktop\хавно за 7 семак\lab1\iarproject.ewp</path>
    </project>
    <batchBuild />
</workspace>
