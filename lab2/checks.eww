<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\checks.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Desktop\lab1\iarproject.ewp</path>
    </project>
    <batchBuild />
</workspace>
